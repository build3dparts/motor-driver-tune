# Keil uVision project Project.uvproj, settings and files
target Open407I (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: Project +hex
  AfterMake: fromelf --bin --output ./output/Project.bin ./output/Project.axf
  c flags: Optim=1 wLevel=1
  c define: STM32F40XX,STM32F4XX, USE_STDPERIPH_DRIVER,MEDIA_USB_KEY,USE_USB_OTG_FS,TM_DISCO_STM32F4_DISCOVERY,STM32F40_41xxx
  c include: ..\User;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32_USB_OTG_Driver\inc;..\Libraries\STM32F4-Discovery;..\Libraries\Third_Party\fat_fs\inc;..\Libraries\STM32_USB_HOST_Library\Core\inc;..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\User\TMLibs
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: stm32f4xx_it.c main.cpp pinout.cpp adc.cpp
  group Startup
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_flash.c stm32f4xx_dma.c stm32f4xx_sdio.c stm32f4xx_dac.c stm32f4xx_i2c.c stm32f4xx_adc.c
    ../Libraries/STM32F4-Discovery/: stm32f4_discovery.c libPDMFilter_Keil.lib
  group CMSIS
    ../Libraries/CMSIS/Include/: core_cm4.h
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_tim.c stm32f4xx_exti.c stm32f4xx_syscfg.c
    ../User/: system_stm32f4xx.c
  group TFTLCD
    ../User/TFTLCD/: lcd_base.cpp ssd1289.cpp terminus.cpp
  group SSD1289_TouchScreen
    ../User/SSD1289_TouchScreen/: TouchPanel.cpp
  group GUI
    ../User/GUI/: Component.cpp EventMethods.cpp GUI.cpp GUIButton.cpp GUIEditBox.cpp GUILabel.cpp GUIProgress.cpp GUITextField.cpp GUIListBox.cpp GUIDesktop.cpp GUISlider.cpp
  group Usart
    ../User/Usart/: UARTLib.c
  group TMLibs
    ../User/TMLibs/: tm_stm32f4_delay.cpp tm_stm32f4_disco.cpp tm_stm32f4_pwm.cpp tm_stm32f4_timer_properties.cpp
